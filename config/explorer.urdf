Commit message: Add supervised LeRobot learning panel and conservative arm and power safeguards

File: config/explorer.urdf (robot description, URDF)
Before this commit: robot explorer, 24 links, 23 joints
Joints:
- joint arm5_Joint: axis 0 -1 0 -> 0 0 1
